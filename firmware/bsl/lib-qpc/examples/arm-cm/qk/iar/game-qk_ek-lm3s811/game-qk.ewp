# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPC_$\include; $_QPC_$\ports\arm-cm\qk\iar; $_QPC_$\ports\arm-cm\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: game-qk.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\qk\iar\dbg\libqp_cortex-m3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\qk\iar\rel\libqp_cortex-m3.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; Q_SPY; STACK_SIZE=600
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\qk\iar\spy\libqp_cortex-m3.a
  group Source
    ./: bsp.c bsp.h display96x16x1.c display96x16x1.h game.h lm3s_config.h main.c mine1.c mine2.c missile.c ship.c startup_lm3s.c system_lm3s.c tunnel.c

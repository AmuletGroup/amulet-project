# Keil uVision project amulet.uvproj, settings and files
target dpp-dbg (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: dpp
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT
  c include: .;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\vanilla\arm_keil;..\..\..\..\..\ports\arm-cm\cmsis
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.c bsp.h dpp.h main.c philo.c table.c startup_keil.s blinky.c blinky.h amulet_actuators.c amulet_actuators.h amulet_sensors.c amulet_sensors.h
  group Library-dbg
    ../../../../../ports/arm-cm/vanilla/arm_keil/dbg/: libqp_Cortex-M4.fp.a
  group Library-rel
    ../../../../../ports/arm-cm/vanilla/arm_keil/rel/: libqp_Cortex-M4.fp.a
  group Library-spy
    ../../../../../ports/arm-cm/vanilla/arm_keil/spy/: libqp_Cortex-M4.fp.a
target dpp-rel (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT NDEBUG
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: as above
  output: dpp
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT Q_SPY
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler

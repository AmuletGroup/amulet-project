# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPC_$\include; $_QPC_$\ports\arm-cm\vanilla\iar; $_QPC_$\ports\arm-cm\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp.bin
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\vanilla\iar\dbg\libqp_cortex-m4f.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\vanilla\iar\rel\libqp_cortex-m4f.a
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=1024
  ICCARM.CCOptLevel: 1
  ILINK.IlinkAdditionalLibs: $_QPC_$\ports\arm-cm\vanilla\iar\spy\libqp_cortex-m4f.a
  group Source
    ./: bsp.c bsp.h dpp.h main.c philo.c startup_tm4c.c table.c
